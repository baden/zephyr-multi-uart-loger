## boards/waveshare_rp2040_zero/board.yml
```yaml
board:
  name: waveshare_rp2040_zero
  vendor: waveshare
  socs:
  - name: rp2040
```
